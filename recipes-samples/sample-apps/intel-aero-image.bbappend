# Sample Applications
IMAGE_INSTALL_append = " sample-apps capturev4l2"

